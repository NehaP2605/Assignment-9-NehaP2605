# Disable native tests
EXTRA_OECMAKE:append:class-native = " -DENABLE_TESTS=OFF"
